ORG 0000h

MOV R6, #00h
MOV R7, #0FFh
MOV R4, #0FFh
MAIN: LCALL MAXMIN

ORG 0100h
MAXMIN: MOV DPTR, #NUMBERS
BACK: CLR A
MOVC A,@A+DPTR
JZ END
MAX: 
CJNE A,6,NEXT1 
LJMP NEXTNUM
NEXT1:
JC MIN         
MOV R6, A      
LJMP NEXTNUM    

MIN:
CJNE A,7, NEXT2 
LJMP NEXTNUM
NEXT2:
JNC NEXTNUM      
MOV R7, A

NEXTNUM: 
INC DPTR
DJNZ R4, BACK
END: RET

ORG 1000h
NUMBERS: DB 12,15,1,25,250,0

END
