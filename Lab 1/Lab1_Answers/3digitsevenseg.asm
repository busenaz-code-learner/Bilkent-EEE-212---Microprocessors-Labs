ORG 00
MOV DPTR,#CODE7
MOV R0,#00
MOV R1,#00H
 MOV R7,#00
UP:LCALL DISP
   INC R0
   CJNE R0,#10,UP
   MOV R0,#00
   INC R1
   CJNE R1,#10,UP
   MOV R1,#00
   inc r7
   cjne r7,#10,up
   mov r7,#00
   JMP UP

DISP:MOV R5,#03H
 UP3:MOV R4,#0FFH
UP2: SETB P3.0
     MOV A,R0
     MOVC A,@A+DPTR
  MOV P1,A
  MOV R3,#0FFH
  UP5:DJNZ 03,UP5
  CLR P3.0 

  SETB P3.1
     MOV A,R1
     MOVC A,@A+DPTR
  MOV P1,A
  MOV R3,#0FFH
  UP1:DJNZ 03,UP1
  CLR P3.1
  SETB P3.3
     MOV A,R7
     MOVC A,@A+DPTR
  MOV P1,A
  MOV R3,#0FFH
  UP6:DJNZ 03,UP6
  CLR P3.3 
  DJNZ 04,UP2
  DJNZ 05,UP3
  RET
ORG 0400H
CODE7: DB 3FH,06H,5BH,4FH,66H,6DH,7DH,07H,7FH,6FH
END 

