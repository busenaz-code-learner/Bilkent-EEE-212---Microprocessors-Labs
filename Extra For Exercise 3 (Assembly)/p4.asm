ORG 0000H
	LJMP MAIN

ORG 000BH
	LJMP INTT0

ORG 001BH
	LJMP INTT1

ORG 0100H

MAIN:

	MOV TMOD, #00010010B
	MOV IE, #10001010B
	
	MOV TL0, #0B9H
	MOV TH0, #0B9H
	
	MOV TH1, #0FBH
	MOV TL1, #50H

	SETB TR1
	SETB P1.6
	SETB TR0
	SETB P1.7

OTHERSTUFF: SJMP $

INTT0:
	CPL P1.7
	RETI

INTT1:
	CLR TR1
	MOV TH1, #0FBH
	MOV TL1, #50H
	CPL P1.6
	RETI

















